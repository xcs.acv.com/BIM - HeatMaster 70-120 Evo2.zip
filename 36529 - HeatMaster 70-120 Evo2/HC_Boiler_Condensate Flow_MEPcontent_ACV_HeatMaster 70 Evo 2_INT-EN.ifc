Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
Time: 2025-10-22T10:05:42+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.1.318 - Exporter 23.0.1.318 - Default UI

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Level 1
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Level 1; Type: Level 1; Type Id: 1899
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1
Other(Type) - Category: Levels; Family Name: Level

# IfcBoiler: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 70-120 Evo2_INT-EN:HeatMaster 70 Evo 2, HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 70-120 Evo2_INT-EN:HeatMaster 70 Evo 2:13391
In: Level 1
Type - Material: Color RGB 073-073-073, Color RGB 222-222-222, Color RGB 237-028-036, Color RGB 187-080-046, Color RGB 143-145-144, Color RGB 129-158-173
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Depth: 823 mm; Domestic Cold Water Diameter: 25.4 mm; Domestic Hot Water Diameter: 25.4 mm; Flue Gas Diameter: 100 mm; Gas Diameter: 19.05 mm; Height: 2170 mm; Hydronic Return Diameter: 38.1 mm; Hydronic Supply Diameter: 38.1 mm; Supply Air Diameter: 150 mm; Use Nominal Diameter: yes; Width: 690 mm
Type - Electrical - Current: 1.5 A; Hertz: 50 Hz; Input: 69900 W; Max Power Boiler: 68000 W; Min Power Boiler: 20900 W; Rated Current (Fuse): 0 A; Voltage: 230 V
Type - Identity Data - Article Description: Combined gas fired condensing boiler and water heater with stainless steel heat exchanger.; Article Type: HeatMaster 70 Evo 2; Base Family Version: 25.12; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Combined gas fired condensing boiler and water heater with stainless steel heat exchanger.; EMCS Version: 5.0; ETIM Article Class: EC011390; Family Version: 25.12; GLN: 5400891000007; GTIN: 5400891542552; Manufacturer: ACV; Manufacturer Art. No.: 554255; Manufacturer URL: https://www.acv.com/international; MEPcontent Class: BOILER_CONDENSATE_FLOW; Model: HeatMaster 70 Evo 2; OmniClass Number: 23.75.10.11.14; OmniClass Title: Hot Water Heat Generators; Product Line: HeatMaster Evo 2; Revit Version: 2023; Type Name: HeatMaster 70 Evo 2; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Blue: Color RGB 129-158-173; Dark Grey: Color RGB 073-073-073; Light Grey: Color RGB 143-145-144; Orange: Color RGB 187-080-046; Red: Color RGB 237-028-036; White: Color RGB 222-222-222
Type - Mechanical - DHW Continuous Flow 60°C: 0.347778 m3/s; Gas Flow Rate Max: 2.01111 m3/s; Gas Flow Rate Min: 0.619444 m3/s; Maximum Supply Temperature (Operating Temperature): 87 C; Max Pressure DHW: 860000 Pa; Max Pressure Heating: 300000 Pa; Total Capacity: 0.315 m3; Weight: 298 kg
Type - Other - Category: Mechanical Equipment; Chimney Agreement: B23-B23P-C13-C33-C53-C63-C83-C82; Class: 6; D: 100 mm; E: 150 mm; F: 180 mm; Family Name: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 70-120 Evo2_INT-EN; G: 2055 mm; H: 125 mm; J: 2110 mm; K: 2015 mm; L: 1735 mm; M: 1535 mm; Maine Body Depth: 785 mm; N: 725 mm; O: 525 mm; P: 285 mm; Profile: XXL; Space Heating Energy Efficiency Class: A; Water Heating Energy Efficiency Class: A
Type - Pset_ManufacturerTypeInformation - Manufacturer: ACV
Pset_BoilerTypeCommon - Reference: HeatMaster 70 Evo 2; sets with these values: 2
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 14.2811 m2; Volume: 1.15993 m3
Electrical - Power: 0 W
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water,Undefined,Hydronic Return,Hydronic Supply,Hydronic Return,Supply Air,Exhaust Air,Power
Mechanical - Flow - Domestic Cold Water Flow: 0 m3/s; Domestic Hot Water Flow: 0 m3/s; Flue Gas Flow: 0 m3/s; Gas Flow: 0 m3/s; Hydronic Return Flow 1: 0 m3/s; Hydronic Return Flow 2: 0 m3/s; Hydronic Supply Flow: 0 m3/s; Supply Air Flow: 0 m3/s
Other - Back Clearance Safe: 400 mm; Family: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 70-120 Evo2_INT-EN; Family and Type: HC_Boiler_Condensate Flow_MEPcontent_ACV_HeatMaster 70-120 Evo2_INT-EN: HeatMaster 70 Evo 2; Left Clearance Safe: 600 mm; Right Clearance Safe: 250 mm; Top Clearance Safe: 300 mm; Type: HeatMaster 70 Evo 2; Type Id: 13313
Phasing - Phase Created: New Construction
Visibility - Back Clearance: 400 mm; Left Clearance: 600 mm; Right Clearance: 250 mm; Service Space: no; Top Clearance: 300 mm

# IfcDistributionPort (9)
Description: Flow
Name | FlowDirection | PredefinedType | SystemType
Port_13391 | SOURCE | DUCT | EXHAUST
Port_13391 | SINK | PIPE
Port_13391 | SOURCE | PIPE | DOMESTICHOTWATER
Port_13391 | SOURCEANDSINK | CABLE | ELECTRICAL
Port_13391 | SOURCE | PIPE | HEATING
Port_13391 | SINK | DUCT | VENTILATION
Port_13391 | SINK | PIPE | DOMESTICCOLDWATER
2 x Port_13391 | SINK | PIPE | HEATING
